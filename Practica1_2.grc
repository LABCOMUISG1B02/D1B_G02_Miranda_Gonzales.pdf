options:
  parameters:
    author: D1BGrupo02
    generate_options: qt_gui
    id: Practica1_2
    output_language: python
    title: gruop
  states: {}

blocks:
- name: samp_rate_0
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: ''
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    label1: '''Original'''
    label2: '''Decimation'''
    label3: '''Interpolation'''
    nconnections: '3'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: original
    label2: Decimation
    label3: interpolation
    nconnections: '3'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.1'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: '0.1'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.1'
    interp: '4'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_sig_source_x_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '2']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0, '2']
- [rational_resampler_xxx_0_0_0, '0', qtgui_freq_sink_x_0, '1']
- [rational_resampler_xxx_0_0_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
