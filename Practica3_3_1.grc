options:
  parameters:
    author: uis-e3t
    category: '[Modulos_D1BGX]'
    generate_options: qt_gui
    id: Practica3_3_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.2'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del Tx
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
    widget: counter
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    orient: Qt.Horizontal
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: ka
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '2'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ModulorAM_D1BG3_0
  id: ModulorAM_D1BG3
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '200000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: GTX
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: '200000'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModulorAM_D1BG3_0, '0', qtgui_time_sink_x_0, '0']
- [ModulorAM_D1BG3_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ModulorAM_D1BG3_0, '0']

metadata:
  file_format: 1
